# Keil uVision project server1.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MKW41Z512xxx4 NXP
  pack: Keil.Kinetis_KWxx_DFP.1.7.0
  cpu: IRAM(0x1FFF8000,0x00020000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: server1
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x20000
  group Source Group 1
    ./: main.c
software components: RTOS:Config 9.0.0, RTOS:Core 9.0.0, RTOS:Event Groups 9.0.0, RTOS:Heap 9.0.0, RTOS:Timers 9.0.0, CMSIS:CORE 5.0.2, CMSIS:RTOS:FreeRTOS 9.0.0, CMSIS:RTOS2:FreeRTOS 9.1.0, Board Support:LED 1.0.0, Network:CORE 7.5.0, Network:Interface:SLIP 7.5.0, Network:Socket:TCP 7.5.0, USB:CORE 6.11.0, USB:Host:CDC 6.11.0, CMSIS Driver:USART:CDC 1.3.0, Device:Startup 1.0.0
